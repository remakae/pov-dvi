# Keil uVision project ceshi.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT87F51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ceshi +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ceshi.c
