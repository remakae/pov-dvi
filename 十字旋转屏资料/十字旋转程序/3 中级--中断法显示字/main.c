#include "STC89C51RC.H"

//初始化外部中断INT2，熄灭所有LED
void init()
{
    //-----------INT2中断初始化-------------------------------------------------   
	EA = 1;		 //中断使能
	IT2 = 0;    //低电平触发中断  
   	EX2 = 1;	//外部中断2使能
	P1=0XFF;
	P2=0XFF;
	P0=0XFF;
	P3=0XFF; 

}




 
bit BIT_timeout=0;
unsigned int i=0,j=0,k=0;

/*********延时子程序**********/
/*****n（us）延时子程序*****/
void DelayUs(unsigned int N)
{
    unsigned int x ;
    for(x=0;x<=N;x++);
}

/*********中断子程序**********/
void int2() interrupt 6	//使用外部中断2
{
	BIT_timeout=1; //起点标志位	
}



#define ucNumRows 176 //定义一周显示字个数 一个字16列 160/16=10个字
extern unsigned char code zimo[];


//主要函数，从zimo[]里面读取数据发送到P0-P3端口推动LED显
void main_loop(void)
{
	 
	if(BIT_timeout)	//起点判断
 	{			
		BIT_timeout=0; //清零
		
		j++; 				           
        if( j>672 )//显示完文字后 循环； j=16*需要显示的字数	 这里大概有120个字符 所以120*16=1920
        {
            j=0 ;
			k^=1;	 //变量K控制哪一边LED发光。一边显示完所有字后换另外一边
        }            
        for(i=ucNumRows+j;i>j;i--)  //立体显示176列 数据   176/16=11个字
        {                               
           	if(k){
				P1=zimo[i*2];	//送数据低位显示
				P3=zimo[i*2+1];//送数据高位显示	
			}
			else
			{
				P2=zimo[i*2];	//送数据低位显示
				P0=zimo[i*2+1];//送数据高位显示		
			}			
			DelayUs(20);
			P0=P1=P2=P3=0XFF;							
          if(BIT_timeout)//这里如果没有显示完一圈的数据 回到起点了 
		                  //直接跳出 就不会出现头吃尾的现象 而且盲点很小
		   {
		   		return;
		   }
		}	   
	}
}


/*********************************************************************************************************
** 函数名称: main
** 功能描述: 主函数，用户程序从这里执行
***************************************************************************************************/

void main(void)
{
    init();
	while(1)
       main_loop();
}




